# Repository KoNarRobotics/ModuCard-nav-module-v2

File README.md:

# ModuCard Nav Module

Second version of the navigation module based on the new BaseModule with STM32H563VBT6 MCU.

## A navigation module is equipped with:

- **GPS RTK ZED-F9P**
- **IMU ICM-20948**
- **IMU BNO055 (mountable on rubber shock absorbers)**
- **Barometer BMP280**

## Used tools:

## Features:

### Power section

- **Input voltage:** 12V from the backplane.
- **Output voltage:** 3.3V @ 0.5A.

### ST-LINK

- Built-in **ST-LINK** connected to the backplane via USB interface.
- Enables programming and debugging of the onboard MCU.

### CAN interface

- Two independent FDCAN buses: **CAN1** and **CAN2**.
- Both connect with the backplane to facilitate communication between the onboard MCU and other modules in the system.

## KiCad design ModuCard-navigation-module.kicad_pcb

Parts:
C500, C501: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
R500: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
U500: TJA1044GTK_3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm; Manufacturer_Part_Number TJA1044GTK/3Z

Connections:
+3V3: C501.1, U500.5 (VIO); also elsewhere on the board
+5V: C500.2, U500.3 (VCC); also elsewhere on the board
/Backplane/CAN1.+: U500.7 (CANH); also elsewhere on the board
/Backplane/CAN1.-: U500.6 (CANL); also elsewhere on the board
/CAN transceiver 1/CAN.RX: U500.4 (RXD); also elsewhere on the board
/CAN transceiver 1/CAN.TX: U500.1 (TXD); also elsewhere on the board
GND: C500.1, C501.2, R500.2, U500.2 (GND), U500.9 (EP); also elsewhere on the board
unnamed: R500.1, U500.8 (STB)

Parts of its further copies:
C600, C601: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
R600: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
U600: TJA1044GTK_3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm; Manufacturer_Part_Number TJA1044GTK/3Z

Connections of its further copies:
+3V3: C601.1, U600.5 (VIO); also elsewhere on the board
+5V: C600.2, U600.3 (VCC); also elsewhere on the board
/Backplane/CAN2.+: U600.7 (CANH); also elsewhere on the board
/Backplane/CAN2.-: U600.6 (CANL); also elsewhere on the board
/CAN transceiver 2/CAN.RX: U600.4 (RXD); also elsewhere on the board
/CAN transceiver 2/CAN.TX: U600.1 (TXD); also elsewhere on the board
GND: C600.1, C601.2, R600.2, U600.2 (GND), U600.9 (EP); also elsewhere on the board
unnamed: R600.1, U600.8 (STB)

Notes on the sheet:
CAN TRANSCEIVER

Parts:
C300, C305, C306, C311: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C301, C302, C303, C304, C309, C310: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
C307, C308: 22uF; C_0603; Voltage Rated 6.3V; Tolerance ±20%; Part CL10A226MQ8NRNC; LCSC C59461
D400, D401, D402: Red; D_0603; Part KT-0603R; LCSC C2286
F300: Fuse; R_0603
JP300, JP301: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L300, L301: L; L_Changjiang_FXL0420
R300, R306: R_Small; R_0402
R301, R307: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R410: 2.2kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2201TCE; LCSC C25879
R411: 470Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF4700TCE; LCSC C25117
R412: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
TP300, TP301, TP302, TP400: TestPoint; TestPoint_Pad_D1.0mm
U300, U301: TPS563200; SOT-23-6

Connections:
+3V3: D402.2, JP301.2 (B), TP302.1; also elsewhere on the board
+5V: D401.2, JP300.2 (B), TP301.1; also elsewhere on the board
+12V: F300.1; also elsewhere on the board
+12V_FUSED: C303.1, C304.1, C305.2, C309.1, C310.1, C311.2, D400.2, F300.2, TP300.1, U300.3 (VIN), U300.5 (EN), U301.3 (VIN), U301.5 (EN)
/Power/+3V3_UNPROTEC: C307.1, C308.1, JP301.1 (A), L301.2, R306.1
/Power/+5V_UNPROTEC: C301.1, C302.1, JP300.1 (A), L300.2, R300.1
/Power/FB_3V3: R306.2, R307.1, U301.4 (VFB)
/Power/FB_5V0: R300.2, R301.1, U300.4 (VFB)
/Power/SW_3V3: C306.2, L301.1, U301.2 (SW)
/Power/SW_5V0: C300.2, L300.1, U300.2 (SW)
/Power/VBST_3V3: C306.1, U301.6 (VBST)
/Power/VBST_5V0: C300.1, U300.6 (VBST)
GND: C301.2, C302.2, C303.2, C304.2, C305.1, C307.2, C308.2, C309.2, C310.2, C311.1, R301.2, R307.2, R410.2, R411.2, R412.2, TP400.1, U300.1 (GND), U301.1 (GND); also elsewhere on the board
unnamed: D400.1, R410.1
unnamed: D401.1, R411.1
unnamed: D402.1, R412.1

Notes on the sheet:
V_{OUT} = 0.765*(1+33k2/10k) = 3.3V
Max expected current = 1.2A
V_{OUT} = 0.765*(1+R302/R307)
Target I_{LED} = 5mA
V_{OUT} = 0.765*(1+R300/R301)
5V DC/DC CONVERTER
V_{OUT} = 0.765*(1+54k9/10k) = 4.96V
POWER INDICATOR LEDs
3V3 DC/DC CONVERTER

Parts:
C312, C800, C801: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
J800: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R800, R801: 5.1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF5101TCE; LCSC C25905
R802, R804: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R803: 22kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2202TCE; LCSC C25768
R805: 330Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF3300TCE; LCSC C25104
U401: TPD2E2U06DCK; SOT-323_SC-70
U801: FSUSB42UMX; UFQFN-10_1.4x1.8; PARTREV 1.25

Connections:
+3V3: C312.1, U801.9 (VCC); also elsewhere on the board
/Backplane/BACKPLANE.D+: U801.5 (HSD1+); also elsewhere on the board
/Backplane/BACKPLANE.D-: U801.4 (HSD1-); also elsewhere on the board
/USB-hub/USBIN1.D+: U801.1 (D+); also elsewhere on the board
/USB-hub/USBIN1.D-: U801.2 (D-); also elsewhere on the board
/USB/CC1: J800.A5 (CC1), R801.1
/USB/CC2: J800.B5 (CC2), R800.1
/USB/USB2S.D+: J800.A6 (D+), J800.B6 (D+), U401.1, U801.7 (HSD2+)
/USB/USB2S.D-: J800.A7 (D-), J800.B7 (D-), U401.2, U801.6 (HSD2-)
/USB/VBUS_IN: C800.1, J800.A4 (VBUS), J800.A9 (VBUS), J800.B4 (VBUS), J800.B9 (VBUS), R802.1
GND: C312.2, C800.2, C801.2, J800.A1 (GND), J800.A12 (GND), J800.B1 (GND), J800.B12 (GND), R800.2, R801.2, R803.2, R804.2, R805.2, U401.3, U801.3 (GND); also elsewhere on the board
unnamed: C801.1, J800.S1 (SHIELD), R805.1
unnamed: R802.2, R803.1, U801.10 (SEL)
unnamed: R804.1, U801.8 (~OE)

Parts:
C1300: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
C1301, C1302: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
U1300: BMP280; Bosch_LGA-8_2x2.5mm_P0.65mm_ClockwisePinNumbering

Connections:
+3V3: C1300.1, C1301.1, C1302.1, U1300.2 (CSB), U1300.6 (VDDIO), U1300.8 (VDD); also elsewhere on the board
/Barometer/BAROMETR_I2C.SCL: U1300.4 (SCK); also elsewhere on the board
/Barometer/BAROMETR_I2C.SDA: U1300.3 (SDI); also elsewhere on the board
GND: C1300.2, C1301.2, C1302.2, U1300.1 (GND), U1300.5 (SDO), U1300.7 (GND); also elsewhere on the board

Parts:
C407, C1106: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
C408, C409, C1107, C1108: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C411: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
H400, H401, H402, H403: MountingHole; MountingHole_3.5mm
IC400: RT9013-18GB; SOT94P279X130-5N; Manufacturer_Part_Number RT9013-18GB; Mouser Part Number 835-RT9013-18GB
J400: Adafruit garbage connector; Molex_KK-254_AE-6410-06A_1x06_P2.54mm_Vertical
Q400, Q401: BSS138; SOT-23
R419: 0Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF0000TCE; LCSC C17168; not fitted
R420: 0Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF0000TCE; LCSC C17168
R421, R422, R424, R426: 4.7kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF4701TCE; LCSC C25900
U400: ICM-20948; InvenSense_QFN-24_3x3mm_P0.4mm

Connections:
+3V3: C407.1, C408.1, C1106.1, C1107.1, IC400.1 (VIN), IC400.3 (EN), J400.2, R422.1, R424.1, U400.13 (VDD); also elsewhere on the board
+5V: J400.1; also elsewhere on the board
/Barometer/BAROMETR_I2C.SCL: J400.4, Q400.3 (D), R422.2; also elsewhere on the board
/Barometer/BAROMETR_I2C.SDA: J400.5, Q401.3 (D), R424.2; also elsewhere on the board
/IMU/IMU_EXT_NRESET: J400.6; also elsewhere on the board
/IMU/IMU_FSYNC: U400.11 (FSYNC); also elsewhere on the board
/IMU/IMU_INT: U400.12 (INT1); also elsewhere on the board
/IMU/L_SCL: Q400.2 (S), R421.2, U400.23 (SCL/SCLK)
/IMU/L_SDA: Q401.2 (S), R426.2, U400.24 (SDA/SDI)
/IMU/VDDIO: C409.1, C411.1, IC400.5 (VOUT), Q400.1 (G), Q401.1 (G), R420.1, R421.1, R426.1, U400.8 (VDDIO), U400.22 (~CS)
GND: C407.2, C408.2, C409.2, C411.2, C1106.2, C1107.2, C1108.2, IC400.2 (GND), J400.3, R419.2, U400.18 (GND), U400.20 (GND); also elsewhere on the board
unnamed: C1108.1, U400.10 (REGOUT)
unnamed: R419.1, R420.2, U400.9 (SDO/AD0)

Parts:
BTN400: TL2243
C313, C314: 18pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG180J500NT; LCSC C1549
C400, C403, C423, C425: 10uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A106MQ5NUNC; LCSC C15525
C401, C402, C404, C405, C406, C415, C416, C420, C421, C422, C424, C426, C432: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C410: 4.7uF; C_0402; Voltage Rated 10V; Tolerance ±20%; Part CL05A475MP5NRNC; LCSC C23733
C427, C434: 2.2uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A225MQ5NSNC; LCSC C12530
FB401: FB_0603; Current Rating 200mA; Tolerance ±25%; Part GZ1608D601TF; LCSC C1002
LED300, LED301: FixLed307
R401: 1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1001TCE; LCSC C11702
R402, R403, R405: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R404, R406: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076
R407, R408, R423, R428: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
R413, R414: 1.2kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1201TCE; LCSC C25862
U403: STM32H563VGTx; LQFP-100_14x14mm_P0.5mm
X300: Q13FC1350000400; FC-135R_L3.2-W1.5; Frequency Tolerance ±20ppm; Part Q13FC13500004; LCSC C32346
Y400: ASE-xxxMHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN OT322512MJBA4SL; LCSC C725989

Connections:
+3V3: C400.1, C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C420.1, C421.1, C422.1, C425.1, C426.1, C432.1, FB401.2, R403.1, R405.1, R413.1, R414.1, R428.1, U403.6 (VBAT), U403.11 (VDD), U403.21 (VREF+), U403.28 (VDD), U403.50 (VDD), U403.73 (VDDUSB), U403.75 (VDD), U403.100 (VDD), Y400.1 (EN), Y400.4 (Vdd); also elsewhere on the board
/Barometer/BAROMETR_I2C.SCL: R414.2, U403.95 (PB8); also elsewhere on the board
/Barometer/BAROMETR_I2C.SDA: R413.2, U403.96 (PB9); also elsewhere on the board
/CAN transceiver 1/CAN.RX: U403.81 (PD0); also elsewhere on the board
/CAN transceiver 1/CAN.TX: U403.82 (PD1); also elsewhere on the board
/CAN transceiver 2/CAN.RX: U403.51 (PB12); also elsewhere on the board
/CAN transceiver 2/CAN.TX: U403.52 (PB13); also elsewhere on the board
/GPS-RTK/GPS_EXINTERUPT: U403.87 (PD6); also elsewhere on the board
/GPS-RTK/GPS_GEOFENCE_STAT: U403.86 (PD5); also elsewhere on the board
/GPS-RTK/GPS_MODE_SELECT: U403.84 (PD3); also elsewhere on the board
/GPS-RTK/GPS_NRESET: U403.83 (PD2); also elsewhere on the board
/GPS-RTK/GPS_RTK_STAT: U403.85 (PD4); also elsewhere on the board
/GPS-RTK/GPS_SPI.CLK: U403.78 (PC10); also elsewhere on the board
/GPS-RTK/GPS_SPI.CS: U403.77 (PA15(JTDI)); also elsewhere on the board
/GPS-RTK/GPS_SPI.MISO: U403.79 (PC11); also elsewhere on the board
/GPS-RTK/GPS_SPI.MOSI: U403.80 (PC12); also elsewhere on the board
/GPS-RTK/GPS_UART.RX: U403.23 (PA0); also elsewhere on the board
/GPS-RTK/GPS_UART.TX: U403.24 (PA1); also elsewhere on the board
/IMU/IMU_EXT_NRESET: U403.39 (PE8); also elsewhere on the board
/IMU/IMU_FSYNC: U403.42 (PE11); also elsewhere on the board
/IMU/IMU_INT: U403.43 (PE12); also elsewhere on the board
/MCU/BOOT0: C410.1, R401.2, R402.1, U403.94 (BOOT0)
/MCU/BOOT_EN: R401.1, U403.93 (PB7)
/MCU/NRST: C415.1, R403.2, R404.1
/MCU/OSC32_IN: C314.1, U403.8 (PC14), X300.2
/MCU/OSC32_OUT: C313.1, U403.9 (PC15), X300.1
/MCU/OSC_IN: U403.12 (PH0), Y400.3 (OUT)
/MCU/QSPI1.CS: U403.47 (PB10); also elsewhere on the board
/MCU/QSPI1.IO0: U403.58 (PD11); also elsewhere on the board
/MCU/QSPI1.IO1: U403.59 (PD12); also elsewhere on the board
/MCU/QSPI1.IO2: U403.1 (PE2); also elsewhere on the board
/MCU/QSPI1.IO3: U403.60 (PD13); also elsewhere on the board
/MCU/QSPI1.SCLK: U403.37 (PB2); also elsewhere on the board
/MCU/STATUS_LED: R408.1, U403.4 (PE5)
/MCU/SWD.SWCLK: U403.76 (PA14(JTCK); also elsewhere on the board
/MCU/SWD.SWDIO: U403.72 (PA13(JTMS); also elsewhere on the board
/MCU/SWD.~RST: BTN400.3, R404.2, U403.14 (NRST); also elsewhere on the board
/MCU/USB_MCU.D+: U403.71 (PA12); also elsewhere on the board
/MCU/USB_MCU.D-: U403.70 (PA11); also elsewhere on the board
/MCU/USER_LED_1: R423.1, U403.2 (PE3)
/MCU/USER_LED_2: R407.1, U403.3 (PE4)
/MCU/USR_BTN: C416.1, R405.2, R406.1
/MCU/USR_BUTTON: BTN400.4, R406.2, U403.5 (PE6)
/MCU/VCAP_1: C427.1, U403.48 (VCAP)
/MCU/VCAP_2: C434.1, U403.98 (VCAP)
/MCU/VDDA: C423.1, C424.1, FB401.1, U403.22 (VDDA)
GND: BTN400.1, BTN400.2, C313.2, C314.2, C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C410.2, C415.2, C416.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C432.2, C434.2, LED300.2, LED300.4, LED301.2, LED301.4, R402.2, U403.10 (VSS), U403.19 (VSSA), U403.20 (VREF-), U403.27 (VSS), U403.49 (VSS), U403.74 (VSS), U403.99 (VSS), Y400.2 (GND); also elsewhere on the board
unnamed: LED300.1, R423.2
unnamed: LED300.3, R407.2
unnamed: LED301.1, R408.2
unnamed: LED301.3, R428.2

Notes on the sheet:
Boot EN can be pulled up with BOOT_EN pin C412 will retain voltage on boot0 pin during MCU reboot routine
GPS
RESET BUTTON
CAN
CRYSTAL RESONATORS
POWER INDICATOR AND USER LEDs
NOTICE:
Target I_{LED} = 5mA
Design choice due: es0565, sec 2.2.3
AVDD
IMU
BULK
USER BUTTON
NOTE: PLACE CAPACTITOR AT PWR PIN

Parts:
BAT1100: CR2032; BatteryHolder_Keystone_1060_1x2032; Part BS-07-A1BJ001; LCSC C2979167
C1100, C1102: 10uF; C_0603; Voltage Rated 25V; Tolerance ±20%; Part CL10A106MA8NRNC; LCSC C96446
C1101, C1103, C1105: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C1104: 47pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG470J500NT; LCSC C1567
D1100: 1N4148W; D_SOD-123; Forward Voltage (Vf@If) 1V@50mA; Reverse Voltage (Vr) 75V; Part 1N4148W; LCSC C81598
D1101, D1102, D1103: Green; D_0603; Part 19-217/GHC-YR1S2/6T; LCSC C2986059
J1100: Conn_Coaxial; SMA_Amphenol_901-143_Horizontal
L1100: 120n; L_0402_1005Metric
R415, R417: 0Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF0000TCE; LCSC C17168
R1100: 1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1001TCE; LCSC C11702
R1101, R1104: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R1102: 10Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF100JTCE; LCSC C25077
R1103: 22Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF220JTCE; LCSC C25092
R1105, R1106, R1107: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
U1100: ZED-F9P; ublox_ZED

Connections:
+3V3: C1100.1, C1101.1, D1100.2, R1101.1, R1104.1, U1100.33 (VCC), U1100.34 (VCC), U1100.38 (V_USB); also elsewhere on the board
/GPS-RTK/GPS_EXINTERUPT: U1100.51 (EXTINT); also elsewhere on the board
/GPS-RTK/GPS_GEOFENCE_STAT: D1101.2, U1100.19 (GEOFENCE_STAT); also elsewhere on the board
/GPS-RTK/GPS_MODE_SELECT: R1104.2, U1100.47 (D_SEL); also elsewhere on the board
/GPS-RTK/GPS_NRESET: R1103.1; also elsewhere on the board
/GPS-RTK/GPS_RTK_STAT: D1102.2, U1100.20 (RTK_STAT); also elsewhere on the board
/GPS-RTK/GPS_SPI.CLK: U1100.45 (SCL/SPI_CLK); also elsewhere on the board
/GPS-RTK/GPS_SPI.CS: U1100.44 (SDA/~SPI_CS); also elsewhere on the board
/GPS-RTK/GPS_SPI.MISO: R417.1; also elsewhere on the board
/GPS-RTK/GPS_SPI.MOSI: R415.2; also elsewhere on the board
/GPS-RTK/GPS_UART.RX: R415.1, U1100.43 (RXD/SPI_MOSI); also elsewhere on the board
/GPS-RTK/GPS_UART.TX: R417.2, U1100.42 (TXD/SPI_MISO); also elsewhere on the board
/GPS-RTK/NRST: C1105.1, R1101.2, R1103.2, U1100.49 (~RESET)
/GPS-RTK/RF_: C1104.2, L1100.2, R1102.1
/GPS-RTK/RF_IN: J1100.1 (In), L1100.1, U1100.2 (RF_IN)
/GPS-RTK/TIMEPULSE: D1103.2, U1100.53 (TIMEPULSE)
/GPS-RTK/USB_GPS.D+: U1100.40 (USB_DP); also elsewhere on the board
/GPS-RTK/USB_GPS.D-: U1100.39 (USB_DM); also elsewhere on the board
/GPS-RTK/VCC_RF: R1102.2, U1100.7 (VCC_RF)
/GPS-RTK/V_BCKP: BAT1100.1, C1102.1, C1103.1, R1100.2, U1100.36 (V_BCKP)
GND: BAT1100.2, C1100.2, C1101.2, C1102.2, C1103.2, C1104.1, C1105.2, J1100.2 (Ext), R1105.2, R1106.2, R1107.2, U1100.1 (GND), U1100.3 (GND), U1100.12 (GND), U1100.14 (GND), U1100.32 (GND), U1100.37 (GND), U1100.41 (GND), U1100.48 (GND), U1100.55 (GND); also elsewhere on the board
unnamed: D1100.1, R1100.1
unnamed: D1101.1, R1105.1
unnamed: D1102.1, R1106.1
unnamed: D1103.1, R1107.1
