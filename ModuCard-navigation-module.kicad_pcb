# Repository KoNarRobotics/ModuCard-nav-module-v2 (continued)

## KiCad design ModuCard-navigation-module.kicad_pcb (continued)

Parts:
C900: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C902: 10uF; C_0402; Voltage Rated 6.3V; Tolerance ±20%; Part CL05A106MQ5NUNC; LCSC C15525
C904: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
D301: Red; D_0603; Part KT-0603R; LCSC C2286
R308: 1kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1001TCE; LCSC C11702
R416, R418, R900, R901, R902, R903: 22Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF220JTCE; LCSC C25092
U302: CH334P; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
Y900: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C904.1, D301.2, U302.15 (5V); also elsewhere on the board
/GPS-RTK/USB_GPS.D+: R418.1; also elsewhere on the board
/GPS-RTK/USB_GPS.D-: R416.1; also elsewhere on the board
/MCU/USB_MCU.D+: R901.1; also elsewhere on the board
/MCU/USB_MCU.D-: R900.1; also elsewhere on the board
/ST-LINK/ST-LINK.D+: R903.1; also elsewhere on the board
/ST-LINK/ST-LINK.D-: R902.1; also elsewhere on the board
/USB-hub/USBIN1.D+: U302.12 (DPU); also elsewhere on the board
/USB-hub/USBIN1.D-: U302.11 (DMU); also elsewhere on the board
/USB-hub/USBOUT1_R.D+: R903.2, U302.4 (DP4)
/USB-hub/USBOUT1_R.D-: R902.2, U302.3 (DM4)
/USB-hub/USB_GPS_.D+: R418.2, U302.8 (DP2)
/USB-hub/USB_GPS_.D-: R416.2, U302.7 (DM2)
/USB-hub/USB_MCU_R.D+: R901.2, U302.6 (DP3)
/USB-hub/USB_MCU_R.D-: R900.2, U302.5 (DM3)
GND: C900.2, C902.2, C904.2, U302.17 (GND), Y900.2, Y900.4; also elsewhere on the board
unnamed: D301.1, R308.2
unnamed: C900.1, C902.1, U302.16 (3V3)
unnamed: R308.1, U302.14 (PGANG)
unnamed: U302.2 (XI), Y900.3
unnamed: U302.1 (XO), Y900.1

Notes on the sheet:
USB HUB TO MCU AND STLINK

Schematic: QSPI FLASH.kicad_sch, ModuCard nav module

Parts:
C100: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
U100: W25Q128; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; Part W25Q128JVSIQ; LCSC C97521

Connections:
+3V3: C100.1, U100.8 (VCC); also elsewhere on the board
/MCU/QSPI1.CS: U100.1 (CS#); also elsewhere on the board
/MCU/QSPI1.IO0: U100.5 (DI); also elsewhere on the board
/MCU/QSPI1.IO1: U100.2 (DO); also elsewhere on the board
/MCU/QSPI1.IO2: U100.3 (IO2); also elsewhere on the board
/MCU/QSPI1.IO3: U100.7 (IO3); also elsewhere on the board
/MCU/QSPI1.SCLK: U100.6 (CLK); also elsewhere on the board
GND: C100.2, U100.4 (GND); also elsewhere on the board

Schematic: st-link.kicad_sch, ModuCard nav module

Parts:
C700: 1uF; C_0402; Voltage Rated 25V; Tolerance ±10%; Part CL05A105KA5NQNC; LCSC C52923
C701, C702, C703, C704, C705, C706: 100nF; C_0402; Voltage Rated 50V; Tolerance ±10%; Part CL05B104KB54PNC; LCSC C307331
C707, C708: 33pF; C_0402; Voltage Rated 50V; Tolerance ±5%; Part 0402CG330J500NT; LCSC C1562
D700, D701: Red; D_0603; Part KT-0603R; LCSC C2286
Q700: MMST3904; Q_SOT-323; Part MMST3904; LCSC C22388837
R409, R429: 220Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF2200TCE; LCSC C25091
R700, R702: 100kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1003TCE; LCSC C25741
R701, R703, R705, R709: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744
R704, R708, R715, R716: 22Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF220JTCE; LCSC C25092
R706: 10kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1002TCE; LCSC C25744; not fitted
R710, R714: 100Ω; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1000TCE; LCSC C25076
R711: 39kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF3902TCE; LCSC C25783
R712: 1.2kΩ; R_0402; Overload Voltage (Max) 50V; Tolerance ±1%; Part 0402WGF1201TCE; LCSC C25862
TP700, TP701, TP702, TP703, TP704, TP705, TP706: TestPoint; TestPoint_Pad_D1.0mm
U700: STM32F103CBTx; LQFP-48_7x7mm_P0.5mm
Y700: Crystal_GND24; CRYSTAL-SMD_4P-L3.2-W2.5-BL; MPN 3225-8.00-20-10-10/4B; LCSC C7424755

Connections:
+3V3: C700.1, C701.1, C702.1, C703.1, C704.1, C705.1, Q700.3 (C), R409.1, R700.1, R701.1, TP702.1, U700.1 (VBAT), U700.9 (VDDA), U700.24 (VDD), U700.36 (VDD), U700.48 (VDD); also elsewhere on the board
+5V: R709.1; also elsewhere on the board
/MCU/SWD.SWCLK: R704.2, R715.1; also elsewhere on the board
/MCU/SWD.SWDIO: R716.1; also elsewhere on the board
/MCU/SWD.~RST: R708.1; also elsewhere on the board
/ST-LINK/CLK: TP705.1, U700.37 (PA14)
/ST-LINK/DIO: TP704.1, U700.34 (PA13)
/ST-LINK/LED: D700.1, D701.2, U700.30 (PA9)
/ST-LINK/ST-LINK.D+: R712.2, U700.33 (PA12); also elsewhere on the board
/ST-LINK/ST-LINK.D-: U700.32 (PA11); also elsewhere on the board
/ST-LINK/STLINK-BOOT0: R702.2, TP703.1, U700.44 (BOOT0)
/ST-LINK/STLINK-OSC_IN: C707.1, U700.5 (PD0), Y700.1
/ST-LINK/STLINK-OSC_OUT: C708.1, U700.6 (PD1), Y700.3
/ST-LINK/STLINK-RST: C706.1, R700.2, U700.7 (NRST)
/ST-LINK/STLINK_RX: TP701.1, U700.13 (PA3)
/ST-LINK/STLINK_TX: TP700.1, U700.12 (PA2)
/ST-LINK/SWO: U700.31 (PA10)
/ST-LINK/USB_RENUM: R710.2, U700.38 (PA15)
GND: C700.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, R429.2, R702.1, R703.2, R705.1, R706.1, R711.2, TP706.1, U700.8 (VSSA), U700.23 (VSS), U700.35 (VSS), U700.47 (VSS), Y700.2, Y700.4; also elsewhere on the board
unnamed: D700.2, R409.2
unnamed: D701.1, R429.1
unnamed: Q700.1 (B), R709.2, R710.1, R711.1
unnamed: Q700.2 (E), R712.1
unnamed: R701.2, R703.1, U700.10 (PA0)
unnamed: R704.1, U700.15 (PA5)
unnamed: R708.2, U700.18 (PB0)
unnamed: R714.2, U700.25 (PB12)
unnamed: R715.2, U700.26 (PB13)
unnamed: R714.1, R716.2, U700.27 (PB14)
unnamed: R705.2, U700.2 (PC13)
unnamed: R706.2, U700.3 (PC14)

Notes on the sheet:
Alternative GD32F103CB
SWD
NOTICE:
C707=C708 = (CL - 4pF) * 2
Monitor voltage rail 3V3 instead of target MCU voltage
https://stm32world.com/wiki/DIY_STM32_Programmer_(ST-Link/V2-1)
CAUTION:
Populate with STM32F103C8, STM32F103CB
Should be 1k5, but we try 1k2 because it is in basic parts
ACTIVITY LED
for providing amazing reverse engeenering of ST-link
MANDATORY CB VERSION
FORCE RENUMERATION OF USB DEVICES
https://github.com/lbthomsen/st-link/tree/master
Credit to:

Schematic: backplane.kicad_sch, ModuCard nav module

Parts:
J200: 09031967921; DIN41612_R_3x32_Female_Horizontal_THT; PARTREV D
U402: TPD2E2U06DCK; SOT-323_SC-70

Connections:
+5V_STDBY: J200.a3, J200.b3, J200.c3
+12V: J200.a11, J200.a12, J200.b11, J200.b12, J200.c11, J200.c12; also elsewhere on the board
+24V: J200.a14, J200.b14, J200.c14
/Backplane/BACKPLANE.D+: J200.a2, U402.2; also elsewhere on the board
/Backplane/BACKPLANE.D-: J200.c2, U402.1; also elsewhere on the board
/Backplane/CAN1.+: J200.a5, J200.b5, J200.c5; also elsewhere on the board
/Backplane/CAN1.-: J200.a6, J200.b6, J200.c6; also elsewhere on the board
/Backplane/CAN2.+: J200.a8, J200.b8, J200.c8; also elsewhere on the board
/Backplane/CAN2.-: J200.a9, J200.b9, J200.c9; also elsewhere on the board
/Backplane/GPIOC0: J200.b16
/Backplane/GPIOC1: J200.b17
/Backplane/GPIOC2: J200.b18
/Backplane/GPIOC3: J200.b19
/Backplane/GPIOC4: J200.b20
/Backplane/GPIOC5: J200.b21
/Backplane/GPIOC6: J200.b22
/Backplane/GPIOC7: J200.b23
/Backplane/GPIOC8: J200.b24
/Backplane/GPIOC9: J200.b25
/Backplane/GPIOC10: J200.b26
/Backplane/GPIOC11: J200.b27
/Backplane/GPIOC12: J200.b28
/Backplane/GPIOC13: J200.b29
/Backplane/GPIOC14: J200.b30
/Backplane/GPIOC15: J200.b31
/Backplane/GPIOL0: J200.a16
/Backplane/GPIOL1: J200.a17
/Backplane/GPIOL2: J200.a18
/Backplane/GPIOL3: J200.a19
/Backplane/GPIOL4: J200.a20
/Backplane/GPIOL5: J200.a21
/Backplane/GPIOL6: J200.a22
/Backplane/GPIOL7: J200.a23
/Backplane/GPIOL8: J200.a24
/Backplane/GPIOL9: J200.a25
/Backplane/GPIOL10: J200.a26
/Backplane/GPIOL11: J200.a27
/Backplane/GPIOL12: J200.a28
/Backplane/GPIOL13: J200.a29
/Backplane/GPIOL14: J200.a30
/Backplane/GPIOL15: J200.a31
/Backplane/GPIOR0: J200.c16
/Backplane/GPIOR1: J200.c17
/Backplane/GPIOR2: J200.c18
/Backplane/GPIOR3: J200.c19
/Backplane/GPIOR4: J200.c20
/Backplane/GPIOR5: J200.c21
/Backplane/GPIOR6: J200.c22
/Backplane/GPIOR7: J200.c23
/Backplane/GPIOR8: J200.c24
/Backplane/GPIOR9: J200.c25
/Backplane/GPIOR10: J200.c26
/Backplane/GPIOR11: J200.c27
/Backplane/GPIOR12: J200.c28
/Backplane/GPIOR13: J200.c29
/Backplane/GPIOR14: J200.c30
/Backplane/GPIOR15: J200.c31
GND: J200.a1, J200.a4, J200.a7, J200.a10, J200.a13, J200.a15, J200.a32, J200.b1, J200.b2, J200.b4, J200.b7, J200.b10, J200.b13, J200.b15, J200.b32, J200.c1, J200.c4, J200.c7, J200.c10, J200.c13, J200.c15, J200.c32, U402.3; also elsewhere on the board

Notes on the sheet:
USB
CAN
POWER FLAGS
USB

Board: 4 copper layers, 100.0 x 100.0 mm, 229 parts (17 on the bottom side), 137 nets.

Other parts of the board:
kibuzzard-67B20BD5: G***; kibuzzard-67B20BD5
kibuzzard-67B63E8D: G***; kibuzzard-67B63E8D
kibuzzard-67B69BE3: G***; kibuzzard-67B69BE3
kibuzzard-67B69BEA: G***; kibuzzard-67B69BEA
kibuzzard-67B219C6: G***; kibuzzard-67B219C6
kibuzzard-67B624A4: G***; kibuzzard-67B624A4
kibuzzard-67B643AC: G***; kibuzzard-67B643AC
kibuzzard-67B643DE: G***; kibuzzard-67B643DE
kibuzzard-67B643EE: G***; kibuzzard-67B643EE
kibuzzard-67B2198C: G***; kibuzzard-67B2198C
kibuzzard-67B6248A: G***; kibuzzard-67B6248A
kibuzzard-67B6249A: G***; kibuzzard-67B6249A
kibuzzard-67B6438D: G***; kibuzzard-67B6438D
kibuzzard-67B37005: G***; kibuzzard-67B37005
kibuzzard-67B37418: G***; kibuzzard-67B37418
kibuzzard-67B37472: G***; kibuzzard-67B37472
kibuzzard-67B62451: G***; kibuzzard-67B62451
kibuzzard-67B62470: G***; kibuzzard-67B62470
kibuzzard-67BE3F52: G***; kibuzzard-67BE3F52
kibuzzard-67E7D86B: G***; kibuzzard-67E7D86B
kibuzzard-6807DF1D: G***; kibuzzard-6807DF1D
kibuzzard-68057A01: G***; kibuzzard-68057A01
kibuzzard-68057A2A: G***; kibuzzard-68057A2A
kibuzzard-68057A18: G***; kibuzzard-68057A18
kibuzzard-68057A21: G***; kibuzzard-68057A21
kibuzzard-68057A36: G***; kibuzzard-68057A36
kibuzzard-68091D50: G***; kibuzzard-68091D50
kibuzzard-680579EA: G***; kibuzzard-680579EA
kibuzzard-6805715D: G***; kibuzzard-6805715D
kibuzzard-68057139: G***; kibuzzard-68057139

## Code that names these connections

File STM32H563VBT6_config.ioc (part):

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Mcu.Name=STM32H563VGTx
Mcu.Package=LQFP100
Mcu.UserName=STM32H563VGTx
PA0.Mode=Asynchronous
PA0.Signal=UART4_TX
PA1.Mode=Asynchronous
PA1.Signal=UART4_RX
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13(JTMS/SWDIO).Mode=Serial_Wire
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=Serial_Wire
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15(JTDI).GPIOParameters=GPIO_Label
PA15(JTDI).GPIO_Label=GPS_SPI_CS
PA15(JTDI).Signal=GPIO_Output
PB10.Mode=quad_mode
PB10.Signal=OCTOSPI1_NCS
PB12.Mode=FDCAN_Activate
PB12.Signal=FDCAN2_RX
PB13.Mode=FDCAN_Activate
PB13.Signal=FDCAN2_TX
PB2.Mode=quad_mode
PB2.Signal=OCTOSPI1_CLK
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=BOOT_EN
PB7.Signal=GPIO_Output
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC14-OSC32_IN(OSC32_IN).Mode=LSE-External-Oscillator
PC14-OSC32_IN(OSC32_IN).Signal=RCC_OSC32_IN
PC15-OSC32_OUT(OSC32_OUT).Mode=LSE-External-Oscillator
PC15-OSC32_OUT(OSC32_OUT).Signal=RCC_OSC32_OUT
PD0.Mode=FDCAN_Activate
PD0.Signal=FDCAN1_RX
PD1.Mode=FDCAN_Activate
PD1.Signal=FDCAN1_TX
PD11.Mode=OCTOSPI1_IO[3\:0]
PD11.Signal=OCTOSPI1_IO0
PD12.Mode=OCTOSPI1_IO[3\:0]
PD12.Signal=OCTOSPI1_IO1
PD13.Mode=OCTOSPI1_IO[3\:0]
PD13.Signal=OCTOSPI1_IO3
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=GPS_NRESET
PD2.Signal=GPIO_Output
PD3.GPIOParameters=GPIO_Label
PD3.GPIO_Label=GPS_MODE_SELECT
PD3.Signal=GPIO_Output
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=GPS_RTK_STAT
PD4.Signal=GPIO_Input
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=GPS_GEOFENCE_STAT
PD5.Signal=GPIO_Input
PD6.GPIOParameters=GPIO_Label
PD6.GPIO_Label=GPS_EXINTERUPT
PD6.Signal=GPIO_Input
PE11.GPIOParameters=GPIO_Label
PE11.GPIO_Label=IMU_FSYNC
PE11.Signal=GPIO_Output
PE12.GPIOParameters=GPIO_Label
PE12.GPIO_Label=IMU_INT
PE12.Signal=GPIO_Output
PE2.Mode=OCTOSPI1_IO[3\:0]
PE2.Signal=OCTOSPI1_IO2
PE3.GPIOParameters=GPIO_Label
PE3.GPIO_Label=USER_LED_1
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Label
PE4.GPIO_Label=USER_LED_2
PE4.Signal=GPIO_Output
PE5.GPIOParameters=GPIO_Label
PE5.GPIO_Label=STATUS_LED
PE5.Signal=GPIO_Output
PE6.GPIOParameters=GPIO_Label
PE6.GPIO_Label=USR_BUTTON
PE6.Signal=GPIO_Input
PE8.Signal=GPIO_Output
PH0-OSC_IN(PH0).Mode=HSE-External-Clock-Source
PH0-OSC_IN(PH0).Signal=RCC_OSC_IN
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=240000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-12-23 [#1] Add unnecessary KiCad files to gitignore
2024-12-23 [#1] Initialize KiCad project
2024-12-23 [#1] Add initial README, add KiCad logo in README
2024-12-23 [#1] Add backplane, ST-LINK, MCU and power sheets, draw connections between them
2024-12-23 [#1] Add pdf schematic
2024-12-23 [#1] Add project author and base project author in schematic and PCB title block
2024-12-23 [#1] Update README: describe features and workflow with this project template
2024-12-24 [#1] Add block diagram
2024-12-24 [#1] Convert block diagram to drawio.svg format
2024-12-24 [#3] Draft ST-LINK schematic
2024-12-24 [#3] Create power supply schematic, add project author
2024-12-29 Add moducard logo
2024-12-30 [#3] Cleanup power supply schematic, add notes and calculations
2024-12-30 [#3] Add TJA1044 CAN transciever library
2024-12-30 [#3] Add CAN transcievers to MCU schematic sheet
2024-12-30 Add HVSON83x3 library with 3d model
2024-12-30 [#3] Add STM32 uC
2024-12-30 [#3] Annotate power and CAN transceiver sheets
2024-12-30 [#3] Finish MCU schematic, adjust schematic page numbering
2024-12-31 Add usb schematic
2025-02-05 [3] Add USB power + data schematic
2025-02-05 [3] Change components to parts from LCSC on power sheet
2025-02-05 [3] Fix schematic sheet descriptions
2025-02-05 [3] Finish ST-LINK schematic
2025-02-05 [3] Add second converter
2025-02-05 [3] Fix power supply schematic, add test points
2025-02-05 [3] Add USB hub, draft new MCU
2025-02-05 [3] Rename USB hub sheet
2025-02-05 [3] Delete USB power switch
2025-02-05 [3] Annotate ST-LINK schematic, fix minor text missalignments
2025-02-06 WIP: Add backplane connector
2025-02-06 [3] Add mcu pinout pt1
2025-02-06 [3] Choose 3u3 inductor and solder jumpers footprints on power schematic
    [3] Choose 3u3 inductor and testpoint footprints
2025-02-06 [2] Create fundamental layout
2025-02-06 [3] Add resistor and test points footprints
2025-02-06 [2] Add footprints to PCB
2025-02-06 [3] Add DIN41612 connector
2025-02-06 [3] Fix schematic typos
2025-02-06 Fix St-link schematic errors
2025-02-06 [3] Fix St-link schematic errors
2025-02-06 Add QSPI flash to MCU
2025-02-07 [3] Fix usb bus issue
2025-02-09 [3] Fix CAN bus naming on schematic
2025-02-09 WIP: [3] Fix USB bus naming on schematic
2025-02-10 [3] Fix buses naming on schematic
2025-02-13 [3] Choose components from JLC, fix connections on the shcematic
2025-02-13 [3] Refactor and annotate schematic
2025-02-13 [3] Clear ERC errors
2025-02-13 [3] Fix MCU NRST connection
2025-02-17 [2] Setup pre-defined track widths and via sizes, start ST-LINK layout
2025-02-17 [2] Update converter layout
2025-02-17 [2] Add JLC4161H stackup
2025-02-17 [#2] Connect CAN transcievers and TVS to backplane connector, setup differential pairs
2025-02-17 [#2] Add TL2243 Description and Datasheet
2025-02-17 [#2] Replace USB switch and power indicator LEDs
2025-02-17 [2] Group more elements
2025-02-17 [#2] Add USB and double button, assign testpoint footprints
2025-02-17 [#2] Add FixLed307 library
2025-02-17 [2] Improve layout
2025-02-17 [#2] Add Upright USB library
2025-02-17 [#2] Change USB connector, add board outline and information about keepout area
2025-02-17 [2] Add footprints
2025-02-17 [2] Change layout
2025-02-17 [#2] Add TL2243 Double stack switch library
2025-02-17 [#2] WIP: Layout DC-DC converters, MCU
2025-02-17 [2] Fix component placements
2025-02-17 [#2] Shield power supply section from MCU
2025-02-17 [#2] Fix MCU model, draft QSPI connection
2025-02-17 [#2] Connect MCU to ST-LINK, route DC-DC converters
2025-02-17 [#2] Position front panel parts, add 3d models, continue layout
2025-02-17 [#2] Add grid and drill origin
2025-02-17 [#2] Route everything except for some test points, fix LED and button configuration
2025-02-17 [#2] Trigger CI on push
2025-02-17 [#2] WIP: Layout USB, ST-LINK, move CAN transcievers
2025-02-17 [#2] Add CI
2025-02-17 [#2] Add LSE oscillator, draft CAN RX/TX tracks, ensure copper balance
2025-02-17 [#2] Add silkscreen description
2025-02-17 [#2] Route front panel components
2025-02-17 Change CH334R to CH334P
2025-02-17 [#2] Length match QSPI
2025-02-17 [#2] WIP: Layout USB
2025-02-17 [#2] Finish layout
2025-02-17 [#2] Fix F.mask line
2025-02-17 [#2] Disable trigger CI on push to branch 2
2025-02-17 Update CI to not generate zip with gerbers, and upload only necessare geber files
2025-02-17 Check in CI if PTH-drl.grb file exists before commiting
2025-02-17 Remove old gerbers and schematic pdf
2025-02-17 Add Open Source Hardware logo
2025-02-17 Add generated schematic PDF and Gerber files
2025-02-18 [#4] Remove unnecesary net labels on MCU
2025-02-18 [#4] Fix power indicator LEDs resistor values
2025-02-18 [#4] Add PESD5V0S2BT library
2025-02-18 [#4] Replace ESD protection with PESD5V0S2BT
2025-02-18 [#4] Remove acid traps
2025-02-18 [#4] Length match USB
2025-02-18 [#4] Rotate USB connector ESD protection
2025-02-18 [#4] Improve schematic aesthetics, color nets
2025-02-18 [#4] Fix crystal resonator symbols
2025-02-18 [#4] Update date
2025-02-19 Fix missing 3d models
2025-02-19 [#8] Finish silk and fix libraries
2025-02-22 Replace %%%%%%%% in PCB file with commit SHA in CI
2025-02-25 Fix spacing of ST-LINK programming test points
2025-02-25 Fix missing not in schematic checkbox tick for symbols on the PCB
2025-02-25 Bump revision to 1.0.1 and update the date
2025-02-25 Clear DRC and ERC errors
2025-02-25 Fix revision on the silkscreen
2025-03-12 Add placeholder render to readme
2025-03-29 [#12] Add GND testpoint
2025-03-29 [#12] Change USB TVS
2025-04-17 [#12] Add missing Y700 data
2025-04-17 [#12] Fix typo on silkscreen
2025-04-17 [#12] Delete jlcpcb folder
2025-04-18 Change MCU and update library
    Changed MCU from H7 to H5 series due to programming issues with external
    loader. Also updated JLCPCB components (not all tho there are still
    arround 18 components to fix)
2025-04-18 [1] Change MCU schematic ERC pass
2025-04-18 [3] Change layout
2025-04-19 [#6] Use KiCad 9 in CI
2025-04-19 [#6] Bump rev to 1.1.0
2025-04-19 [#5] Add Y400 MPN
2025-04-20 [REV2] board finshed, schematics and leyout
2025-04-22 addd nice silkinfo
2025-04-23 update for imu
2025-04-23 fixed 5v line and drc
2025-04-24 [mcu] changed mcu from 562VGT6 to 563VGT6
2025-05-12 [imu] added ligic lever shifter and 1.8V power supply
2025-05-15 changed shity resisrto to smaller one on LEDs fixed level shifting
